# Keil uVision project 2024_Sentinel_Chassis.uvprojx, settings and files
target 2024_Sentinel_Chassis (6190000::V6.19::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2024_Sentinel_Chassis +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Libraries/TRoMaC_common;../Libraries/TRoMaC_device;../Application;../Task;../Libraries/TRoMaC_device/DR16;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Task/Referee;../Libraries/TRoMaC_device/OLEDKeyboard;../MDK-ARM
  asm include: ..\Core\Inc;../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c crc.c dma.c rtc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group TRoMaC_Common
    ../Libraries/TRoMaC_common/: headfiles.h Fun.c Fun.h pid.c pid.h bsp_iic.c bsp_iic.h DeviceCheck.c DeviceCheck.h Simiic.c Simiic.h
  group TRoMaC_Device
    ../Libraries/TRoMaC_device/: Motor.c Motor.h
    ../Libraries/TRoMaC_device/DR16/: rc_SBUS.c rc_SBUS.h monitoring_key.c monitoring_key.h
  group Tasks
    ../Task/: debugTask.c debugTask.h ChassisTask.c ChassisTask.h Dart.c Dart.h Auto_Load.c Auto_Load.h
  group Application
    ../Application/: Ctrl.c Ctrl.h log.txt Vision.c Vision.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Referee
    ../Task/Referee/: referee_usart.c referee_usart.h Referee.c Referee.h crc.c crc.h
  group TRoMac_OLED
    ../Libraries/TRoMaC_device/OLEDKeyboard/: dev_CH455.c dev_CH455.h dev_ssd1306.c dev_ssd1306.h FlashFun.c FlashFun.h Font.c Font.h OLEDkeyboard.c OLEDkeyboard.h OLEDkeyboard_Config.c OLEDkeyboard_Config.h OLEDFun.c OLEDFun.h
software components: CMSIS:CORE 5.6.0
